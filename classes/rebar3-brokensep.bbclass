#B = "${S}"
#B = "${WORKDIR}/build"
export REBAR_BASE_DIR = "${S}/_build"